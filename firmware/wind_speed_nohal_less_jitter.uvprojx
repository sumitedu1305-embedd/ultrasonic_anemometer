# Keil uVision project wind_speed_nohal_less_jitter.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32L476RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: wind_speed_nohal_less_jitter
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c main.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Device:Startup 1.3.2
